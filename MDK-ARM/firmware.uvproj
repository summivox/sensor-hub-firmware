# Keil uVision project firmware.uvproj, settings and files
target firmware Configuration (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: firmware Configuration
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F100xB, ARM_MATH_CM3
  c include: ..\user; ..\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Drivers/CMSIS/Lib/: arm_cortexM3l_math.lib
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f100xb.s
  group Application/User
    ../Src/: usart.c adc.c gpio.c dma.c tim.c stm32f1xx_hal_msp.c spi.c main.c stm32f1xx_it.c
  group (actual user code)
    ../user/: user_main.cpp chain.cpp chain.hpp analog.cpp analog.hpp
  group system
    ../system/: retarget_impl.cpp retarget.c retarget.h RTX_Config.c
